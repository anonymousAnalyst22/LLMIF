# IAR project SampleSwitch.ewp, settings and files
configuration Coordinator (ARM, debug)
  General.OGChipSelectEditMenu: CC2538SF53 TexasInstruments CC2538SF53
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS
  ICCARM.CCDiagSuppress: Pa082
  ICCARM.IExtraOptions: -f ..\..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\..\Tools\CC2538DB\f8wCoord.cfg; -f ..\..\..\Tools\CC2538DB\f8wZCL.cfg
  ICCARM.CCIncludePath2: ..\Source; ..\..\Source; ..\..\..\Zmain\TI2538DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf05\single_chip; ..\..\..\..\..\Components\mac\low_level\srf05; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $PROJ_DIR$; ..\Application
  OBJCOPY.OOCOutputFile: SampleSwitch.bin
  ILINK.IlinkOutputFile: SampleSwitch.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538.icf
  ILINK.IlinkAdditionalLibs: ..\..\..\Libraries\CC2538\bin\Router.a; ..\..\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Router (ARM, debug)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f ..\..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\..\Tools\CC2538DB\f8wRouter.cfg; -f ..\..\..\Tools\CC2538DB\f8wZCL.cfg
configuration EndDevice (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS
  ICCARM.IExtraOptions: -f ..\..\..\Tools\CC2538DB\f8wConfig.cfg; -f ..\..\..\Tools\CC2538DB\f8wEndev.cfg; -f ..\..\..\Tools\CC2538DB\f8wZCL.cfg
  ILINK.IlinkAdditionalLibs: ..\..\..\Libraries\CC2538\bin\EndDevice.a; ..\..\..\Libraries\TIMAC\bin\TIMAC-CC2538.a; ..\..\..\..\..\Components\driverlib\cc2538\bin\iar\sdriverlib.lib; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\bin\iar\bsp.lib
configuration EndDevice - OTAClient - ImageA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; HAL_IMG_AREA=0
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: ..\Source; ..\..\Source; ..\..\..\Zmain\TI2538DB; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2538; ..\..\..\..\..\Components\driverlib\cc2538\inc; ..\..\..\..\..\Components\driverlib\cc2538\source; ..\..\..\..\..\Components\sdriverlib\cc2538\source; ..\..\..\..\..\Components\bsp\srf06eb_cc2538\drivers\source; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf05\single_chip; ..\..\..\..\..\Components\mac\low_level\srf05; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\bdb; ..\..\..\..\..\Components\stack\gp; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sapi; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zcl; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\OTA\Source; ..\..\..\..\..\Components\osal\mcu\cc2538
  OBJCOPY.OOCOutputFile: EndDevice-OTAClient-ImageA.bin
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "EndDevice - OTAClient - ImageA\Exe\EndDevice-OTAClient-ImageA.bin" -o"EndDevice - OTAClient - ImageA\Exe" -t0x2538 -m0xBEBE -vAAAA0000  -pCC2538
  ILINK.IlinkOutputFile: EndDevice-OTAClient-ImageA.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-A.icf
  ILINK.IlinkAdditionalLibs: as above
configuration EndDevice - OTAClient - ImageB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; HAL_IMG_AREA=1
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: EndDevice-OTAClient-ImageB.bin
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "EndDevice - OTAClient - ImageB\Exe\EndDevice-OTAClient-ImageB.bin" -o"EndDevice - OTAClient - ImageB\Exe" -t0x2538 -m0xBEBE -vBBBB2000  -pCC2538
  ILINK.IlinkOutputFile: EndDevice-OTAClient-ImageB.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-B.icf
  ILINK.IlinkAdditionalLibs: as above
configuration EndDevice - OTAClient - ImageA - withBootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xPOWER_SAVING; NWK_AUTO_POLL; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; OTA_INITIAL_IMAGE; HAL_IMG_AREA=0
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: EndDevice-OTAClient-ImageA-withBootloader.bin
  ILINK.IlinkOutputFile: EndDevice-OTAClient-ImageA-withBootloader.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-A.icf
  ILINK.IlinkAdditionalLibs: as above
configuration Router - OTAClient - ImageA (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; HAL_IMG_AREA=0
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Router-OTAClient-ImageA.bin
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "Router - OTAClient - ImageA\Exe\Router-OTAClient-ImageA.bin" -o"Router - OTAClient - ImageA\Exe" -t0x2538 -m0xBEBE -vAAAA0000  -pCC2538
  ILINK.IlinkOutputFile: Router-OTAClient-ImageA.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-A.icf
configuration Router - OTAClient - ImageB (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; HAL_IMG_AREA=1
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  OBJCOPY.OOCOutputFile: Router-OTAClient-ImageB.bin
  postbuild: "..\..\..\..\tools\OTA\OtaConverter\Release\OtaConverter.exe" "Router - OTAClient - ImageB\Exe\Router-OTAClient-ImageB.bin" -o"Router - OTAClient - ImageB\Exe" -t0x2538 -m0xBEBE -vBBBB1000  -pCC2538
  ILINK.IlinkOutputFile: Router-OTAClient-ImageB.out
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-B.icf
configuration Router - OTAClient - ImageA - withBootloader (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; CC2538_USE_ALTERNATE_INTERRUPT_MAP=1; FEATURE_RESET_MACRO; SECURE=1; TC_LINKKEY_JOIN; NV_INIT; NV_RESTORE; xZTOOL_P1; xMT_TASK; xMT_APP_FUNC; xMT_SYS_FUNC; xMT_ZDO_FUNC; xMT_APP_CNF_FUNC; LCD_SUPPORTED=DEBUG; MULTICAST_ENABLED=FALSE; ZCL_READ; ZCL_DISCOVER; ZCL_WRITE; ZCL_BASIC; ZCL_IDENTIFY; ZCL_ON_OFF; ZCL_GROUPS; OTA_CLIENT=TRUE; OTA_HA; OTA_MANUFACTURER_ID=0xBEBE; OTA_TYPE_ID=0x2538; OTA_INITIAL_IMAGE; HAL_IMG_AREA=0
  ICCARM.IExtraOptions: as above
  ICCARM.CCIncludePath2: as above
  ILINK.IlinkOutputFile: Router-OTAClient-ImageA-withBootloader.out
  ILINK.IlinkKeepSymbols: bootloader
  ILINK.IlinkIcfFile: ..\..\..\Tools\CC2538DB\CC2538-OTA-Image-A.icf
  group Application
    ../Source/: OSAL_SampleSw.c zcl_samplesw.c zcl_samplesw.h zcl_samplesw_data.c
    ../../Source/: zcl_sampleapps_ui.c zcl_sampleapps_ui.h
  group BDB
    ../../../../../Components/stack/bdb/: bdb.c bdb.h bdb_FindingAndBinding.c bdb_interface.h bdb_Reporting.c bdb_Reporting.h bdb_tlCommissioning.c bdb_tlCommissioning.h bdb_touchlink.c bdb_touchlink.h bdb_touchlink_initiator.c bdb_touchlink_initiator.h bdb_touchlink_target.c bdb_touchlink_target.h
  group GP
    ../../../../../Components/stack/GP/: cGP_stub.h dGP_stub.h gp_common.c gp_common.h gp_interface.h gp_proxyTbl.c
  group HAL/Common
    ../../../../../Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    ../../../../../Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_defs.h hal_drivers.h hal_flash.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/Drivers
    ../../../../../Components/hal/target/CC2538/: hal_adc.c hal_aes.c hal_ccm.c hal_key.c hal_lcd.c hal_led.c hal_mac_cfg.c hal_ota.c hal_sleep.c hal_sys_ctrl.c hal_systick.c hal_uart.c startup_ewarm.c
  group HAL/Target/Include
    ../../../../../Components/hal/target/CC2538/: hal_aes.h hal_board_cfg.h hal_ccm.h hal_mac_cfg.h hal_mcu.h hal_ota.h hal_sys_ctrl.h hal_systick.h hal_types.h iocc2538.h
  group MAC/High Level
    ../../../../../Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.c mac_pib.h mac_spec.h
  group MAC/Include
    ../../../../../Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    ../../../../../Components/mac/low_level/srf05/: mac_assert.h mac_autopend.c mac_autopend.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    ../../../../../Components/mac/low_level/srf05/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h mac_radio_reg_defs.h mac_rffrontend.c
  group MT
    ../../../../../Components/mt/: DebugTrace.c DebugTrace.h MT.c MT.h MT_AF.c MT_AF.h MT_APP.c MT_APP.h MT_APP_CONFIG.c MT_APP_CONFIG.h MT_DEBUG.c MT_DEBUG.h MT_GP.c MT_GP.h MT_NWK.c MT_NWK.h MT_RPC.h MT_SYS.c MT_SYS.h MT_TASK.c MT_TASK.h MT_UART.c MT_UART.h MT_UTIL.c MT_UTIL.h MT_VERSION.c MT_VERSION.h MT_ZDO.c MT_ZDO.h
  group NWK
    ../../../../../Components/stack/nwk/: AddrMgr.h APS.h aps_frag.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.c BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h stub_aps.c stub_aps.h
    ../../../../../Components/stack/sys/: ZDiags.c ZDiags.h ZGlobals.c ZGlobals.h
  group OSAL
    ../../../../../Components/osal/mcu/cc2538/: armcm3flashutil.c armcm3flashutil.h osal_nv.c
    ../../../../../Components/osal/include/: comdef.h OSAL.h OSAL_Clock.h OSAL_Memory.h OSAL_Nv.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
    ../../../../../Components/osal/common/: OSAL.c OSAL_Clock.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Timers.c
  group Profile
    ../../../../../Components/stack/af/: AF.c AF.h
    ../../../../../Components/stack/zcl/: zcl.c zcl.h zcl_diagnostic.c zcl_diagnostic.h zcl_general.c zcl_general.h zcl_green_power.c zcl_green_power.h zcl_ota.c zcl_ota.h
    ../../Source/: zcl_ha.c zcl_ha.h
  group Security
    ../../../../../Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    ../../../../../Components/services/saddr/: saddr.c saddr.h
    ../../../../../Components/services/sdata/: sdata.h
  group Tools
    ../../../Tools/CC2538DB/: CC2538-OTA-Image-A.icf CC2538-OTA-Image-B.icf CC2538.icf f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg f8wZCL.cfg
  group ZDO
    ../../../../../Components/stack/zdo/: ZDApp.c ZDApp.h ZDConfig.c ZDConfig.h ZDNwkMgr.c ZDNwkMgr.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    ../../../../../Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    ../../../../../Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2538DB/: OnBoard.c OnBoard.h ZMain.c
